# IAR project addons_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\sam\utils\header_files; ..; ..\..; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards\atpl360mb; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\boards; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: addons_bootloader_flash.bin
  ILINK.IlinkOutputFile: addons_bootloader_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\sam4cxx_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_1.h sam4cmp16c_0.h sam4cms4c_1.h system_sam4cm.h sam4cms8c_0.h sam4cms16c_1.h sam4cms4c_0.h sam4cm.h sam4cmp8c_0.h sam4cms16c_0.h sam4cmp16c_1.h sam4cmp8c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../sam/utils/cmsis/sam4cm/include/instance/: tc1.h usart0.h aes.h rstc.h slcdc.h cmcc0.h piob.h matrix1.h adc.h rswdt.h chipid.h pmc.h cmcc1.h usart2.h pioa.h pwm.h pioc.h tc0.h ipc0.h rtc.h spi0.h matrix0.h smc1.h ipc1.h icm.h usart3.h uart0.h wdt.h twi0.h supc.h spi1.h twi1.h usart1.h uart1.h smc0.h efc.h rtt.h trng.h gpbr.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../sam/utils/cmsis/sam4cm/include/component/: wdt.h pio.h rswdt.h tc.h smc.h rtt.h usart.h aes.h trng.h rstc.h pdc.h rtc.h adc.h efc.h chipid.h ipc.h gpbr.h cmcc.h pwm.h supc.h pmc.h spi.h slcdc.h icm.h uart.h matrix.h twi.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp16c.h sam4cms8c.h sam4cms16c.h sam4cmp8c.h sam4cms4c.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/boards/atpl360mb
    ../../../../../../sam/boards/atpl360mb/: init.c atpl360mb.h led.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/prime_ng/addons/bootloader
    ../../: bootloader.c
  group thirdparty/prime_ng/addons/bootloader/sam4cms16c_atpl360mb
    ../: conf_boot_regions.h conf_clock.h conf_sleepmgr.h conf_board.h conf_version.h
  group thirdparty/prime_ng/addons/bootloader/sam4cms16c_atpl360mb/iar
    ./: asf.h
