# IAR project addons_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=PL360G55CF_EK; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\ioport; ..\..; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\utils\preprocessor; ..; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\boards\pl360g55cf_ek; ..\..\..\..\..\..\sam\boards; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=PL360G55CF_EK; __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: addons_bootloader_flash.bin
  ILINK.IlinkOutputFile: addons_bootloader_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\samg_flash_isp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55.h system_samg55.h samg55j19.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: twi5.h pdmic1.h usart2.h pmc.h usart0.h udp.h usart7.h flexcom6.h wdt.h cmcc.h twi7.h uhp.h supc.h usart5.h usart3.h i2sc0.h piob.h efc.h spi5.h spi7.h flexcom7.h rtt.h flexcom5.h mem2mem.h matrix.h tc0.h crccu.h twi3.h rstc.h twi1.h spi1.h spi3.h twi6.h i2sc1.h chipid.h flexcom0.h spi4.h flexcom3.h flexcom1.h tc1.h flexcom4.h pdmic0.h twi2.h spi6.h twi0.h spi0.h pioa.h spi2.h adc.h rtc.h usart6.h usart1.h usart4.h gpbr.h flexcom2.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h pmc.h supc.h matrix.h efc.h cmcc.h flexcom.h rtc.h adc.h rstc.h i2sc.h crccu.h pio.h pdmic.h mem2mem.h udp.h pdc.h gpbr.h usart.h spi.h rtt.h chipid.h twi.h tc.h wdt.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/boards/pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c led.h pl360g55cf_ek.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/prime_ng/addons/bootloader
    ../../: bootloader.c
  group thirdparty/prime_ng/addons/bootloader/samg55j19_pl360g55cf_ek
    ../: conf_sleepmgr.h conf_boot_regions.h conf_clock.h conf_board.h conf_version.h
  group thirdparty/prime_ng/addons/bootloader/samg55j19_pl360g55cf_ek/iar
    ./: asf.h
