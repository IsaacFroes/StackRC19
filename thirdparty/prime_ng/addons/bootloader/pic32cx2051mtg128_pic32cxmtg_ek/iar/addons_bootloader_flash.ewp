# IAR project addons_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTG128 Microchip PIC32CX2051MTG128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD=PIC32CXMTG_EK; ARM_MATH_CM4=true; __PIC32CX2051MTG128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\boards; ..; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\sam\boards\pic32cxmtg_ek; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\sam\drivers\efc; ..\..; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\sam\drivers\sfr; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: addons_bootloader_flash.bin
  ILINK.IlinkOutputFile: addons_bootloader_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\pic32cx_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group sam/boards/pic32cxmtg_ek
    ../../../../../../sam/boards/pic32cxmtg_ek/: init.c pic32cxmtg_ek.h led.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx2051mtsh128S1.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg64.h pic32cx1025mtg128.h pic32cx5112mtc128S1.h pic32cx2051mtc128S1.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx1025mtg64.h pic32cx5112mtsh128.h pic32cx1025mtsh128S1.h pic32cx1025mtc128.h pic32cx5112mtsh128S1.h system_pic32cxmt.h pic32cx5112mtc128.h pic32cx1025mtc128S1.h pic32cxmt.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: flexcom4.h spi7.h twi2.h twi0.h twi6.h pmc.h twi7.h flexcom2.h matrix2.h usart7.h spi5.h dwdt.h flexcom6.h twi4.h mem2mem0.h matrix0.h spi4.h rstc.h tc0.h trng.h usart0.h usart2.h usart6.h sha.h emafe.h sfr.h aes.h sfrbu.h cmcc1.h spi3.h cpkcc.h tc1.h spi1.h gpbr.h pio.h rtc.h flexcom0.h tc2.h cmcc0.h slcdc.h usart3.h acc.h qspi.h sefc1.h adc.h flexcom5.h spi2.h matrix3.h syscwp.h twi1.h mcspi.h matrix1.h spi0.h twi5.h uart.h flexcom3.h usart5.h tc3.h flexcom1.h aesb.h pwm.h icm.h rtt.h usart4.h sefc0.h usart1.h chipid.h spi6.h twi3.h flexcom7.h supc.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: flexcom.h sfr.h rtt.h mem2mem.h sefc.h emafe.h tc.h twi.h rtc.h supc.h pmc.h qspi.h rstc.h slcdc.h pdc.h acc.h uart.h trng.h mcspi.h aes.h dwdt.h icm.h spi.h pio.h cmcc.h cpkcc.h adc.h chipid.h pwm.h usart.h sha.h aesb.h syscwp.h matrix.h gpbr.h sfrbu.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtc128.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx5112mtc128.h pic32cx1025mtg64.h pic32cx1025mtg128.h pic32cx2051mtc128.h pic32cx2051mtg64.h pic32cx5112mtsh128.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/sfr
    ../../../../../../sam/drivers/sfr/: sfr.c sfr.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/prime_ng/addons/bootloader
    ../../: bootloader.c
  group thirdparty/prime_ng/addons/bootloader/pic32cx2051mtg128_pic32cxmtg_ek
    ../: conf_version.h conf_boot_regions.h conf_clock.h conf_sleepmgr.h conf_board.h
  group thirdparty/prime_ng/addons/bootloader/pic32cx2051mtg128_pic32cxmtg_ek/iar
    ./: asf.h
