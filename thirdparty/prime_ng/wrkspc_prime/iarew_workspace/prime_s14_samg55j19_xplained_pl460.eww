<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
	<project>
		<path>$WS_DIR$\..\..\addons\bootloader\samg55j19_xplained_pl460\iar\addons_bootloader_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\bin_service\prime_service_bin_1_3\samg55_pl460_bin\iar\bin_service_prime_service_bin_1_3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\bin_service\prime_service_bin_1_4\samg55_pl460_bin\iar\bin_service_prime_service_bin_1_4_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_service_dual_modem\samg55j19_xplained_pl460_bootloader\iar\apps_prime_service_dual_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_service_dual_dlms\samg55j19_xplained_pl460_bootloader\iar\apps_prime_service_dual_dlms_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_hybrid_phy_sniffer_tool\samg55j19_xplained_pl460\iar\apps_prime_hybrid_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_tester_tool\samg55j19_xplained_pl460\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_tx_test_console\samg55j19_xplained_pl460\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_plc_and_go\samg55j19_xplained_pl460\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>
			<member>
				<project>addons_bootloader_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>bin_service_prime_service_bin_1_3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>bin_service_prime_service_bin_1_4_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_service_dual_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_service_dual_dlms_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_hybrid_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>