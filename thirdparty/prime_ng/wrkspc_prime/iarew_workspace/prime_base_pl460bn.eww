<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_1_3_base_modem\same70q21_pl360bn\iar\apps_prime_1_3_base_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_1_3_base_modem\same70q21_pl360bn_s\iar\apps_prime_1_3_base_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_1_3_base_slave_modem\same70q21_pl360bn\iar\apps_prime_1_3_base_slave_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_1_4_base_modem\same70q21_pl360bn\iar\apps_prime_1_4_base_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_1_4_base_modem\same70q21_pl360bn_s\iar\apps_prime_1_4_base_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_sniffer_tool\same70q21_pl360bn\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_tester_tool\same70q21_pl360bn\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_tx_test_console\same70q21_pl360bn\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>
			<member>
				<project>apps_prime_1_3_base_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_1_3_base_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_1_3_base_slave_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_1_4_base_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_1_4_base_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>