<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
	<project>
		<path>$WS_DIR$\..\..\addons\bootloader\sam4cms16c_atpl360mb\iar\addons_bootloader_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\bin_service\prime_service_bin_1_3\sam4c_atpl360b_bin\iar\bin_service_prime_service_bin_1_3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\bin_service\prime_service_bin_1_4\sam4c_atpl360b_bin\iar\bin_service_prime_service_bin_1_4_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_service_dual_modem\sam4cms16c_atpl360mb_bootloader\iar\apps_prime_service_dual_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\apps\prime_service_dual_dlms_met\sam4cms16c_atpl360mb_bootloader\iar\apps_prime_service_dual_dlms_met_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_sniffer_tool\sam4cms16c_atpl360mb\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_tester_tool\sam4cms16c_atpl360mb\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_tx_test_console\sam4cms16c_atpl360mb\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\phy\atpl360\apps\phy_plc_and_go\sam4cms16c_atpl360mb\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>
			<member>
				<project>addons_bootloader_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>bin_service_prime_service_bin_1_3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>bin_service_prime_service_bin_1_4_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_service_dual_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_prime_service_dual_dlms_met_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>