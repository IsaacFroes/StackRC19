# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __FREERTOS__; BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\..\..\common\services\ioport; ..; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\..\..\sam\components\display\c0216CiZ; ..\..\..\..\..\..\..\..\sam\utils; ..\..; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\..\..\sam\boards\atpl360mb; ..\..\..\..\..\..\..\..\common\services\twi; ..\..\..\..\coup_tx_config; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\hal; ..\..\..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates; ..\..\..\..\coup_tx_config\app_wrp\phy_app; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\sam\drivers\twi; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\coup_tx_config\coup_conf\pl360_plcoupxxx; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\sam4cm\iar\sam4cms16c_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME_2CHN.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/aes
    ../../../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/boards/atpl360mb
    ../../../../../../../../sam/boards/atpl360mb/: init.c atpl360mb.h led.h
  group sam/services/timer_1us
    ../../../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_sam4c
    ../../../../../../../../sam/services/timer_1us/hal_sam4c/: timer_1us_hal.c
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cmp16c_0.h sam4cms8c_1.h sam4cms4c_1.h system_sam4cm.h sam4cms8c_0.h sam4cms4c_0.h sam4cms16c_1.h sam4cms16c_0.h sam4cm.h sam4cmp16c_1.h sam4cmp8c_0.h sam4cmp8c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: aes.h rstc.h tc1.h cmcc0.h twi1.h piob.h pmc.h matrix1.h uart0.h adc.h usart0.h usart2.h cmcc1.h trng.h rswdt.h pioc.h tc0.h pwm.h pioa.h spi0.h matrix0.h ipc0.h chipid.h ipc1.h slcdc.h icm.h wdt.h usart3.h smc1.h supc.h spi1.h twi0.h efc.h smc0.h uart1.h usart1.h rtt.h gpbr.h rtc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp16c.h sam4cms16c.h sam4cmp8c.h sam4cms8c.h sam4cms4c.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/component/: wdt.h tc.h pio.h rswdt.h rtt.h rstc.h aes.h trng.h usart.h rtc.h chipid.h adc.h efc.h ipc.h cmcc.h gpbr.h pwm.h pmc.h supc.h spi.h pdc.h slcdc.h icm.h matrix.h uart.h twi.h smc.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/components/display/c0216CiZ
    ../../../../../../../../sam/components/display/c0216CiZ/: c0216CiZ.c c0216CiZ.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: queue.c FreeRTOS_CLI.c list.c tasks.c timers.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: portable.h queue.h projdefs.h FreeRTOS_CLI.h FreeRTOS.h mpu_wrappers.h semphr.h StackMacros.h croutine.h list.h task.h timers.h
  group thirdparty/prime_ng/hal
    ../../../../../../hal/: hal_plc.c hal_aes.c hal_usart.c hal_at45db32.c hal_reset_handler.c hal_uart.c hal.c hal_pcrc.c hal_usi.c hal_trng.c hal_fu.c hal_pib.c hal_cfg.c hal_null_dev.c hal_private.h hal_regions.h conf_prf_if.h hal.h conf_timer_1us.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl360_plcoupxxx
    ../../../../coup_tx_config/coup_conf/pl360_plcoupxxx/: coup_conf.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: plcoup006_2chn.h plcoup007_chn_1.h plcoup011_2chn.h plcoup011_chn_fcc.h plcoup006_chn_fcc.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/phy_app
    ../../../../coup_tx_config/app_wrp/phy_app/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console
    ../../: phy_embedded_app.c phy_tx_test_console.c phy_embedded_app.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console/sam4cms16c_atpl360mb
    ../: conf_app_example.h conf_clock.h conf_sleepmgr.h conf_c0216CiZ.h conf_board.h FreeRTOSConfig.h conf_hal.h conf_atpl360.h conf_uart_serial.h conf_usi.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console/sam4cms16c_atpl360mb/iar
    ./: asf.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../../../common/services/clock/sam4cm/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/twi
    ../../../../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360_IB.c atpl360.c atpl360_hal_spi.c atpl360_boot.h atpl360_IB.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_IB_db.c atpl360_IB_db.h atpl360_comm.h general_defs.h
  group common/components/plc/atpl360/addons
    ../../../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if_prime.c serial_if.c serial_if.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
