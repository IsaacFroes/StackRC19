# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FREERTOS__; BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\..\..\sam\utils; ..\..; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\coup_tx_config; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..; ..\..\..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\coup_tx_config\coup_conf\pl460; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\hal; ..\..\..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\coup_tx_config\app_wrp\phy_app; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtxx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME_2CHN.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../../../common/services/clock/pic32cx/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/pic32cx_gpio
    ../../../../../../../../common/services/gpio/pic32cx_gpio/: pic32cx_gpio.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c atpl360_IB.c atpl360_hal_spi.c atpl360_boot.h atpl360_IB.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h atpl360_hal_spi.h
  group common/components/plc/atpl360/addons
    ../../../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if.c serial_if_prime.c serial_if.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_IB_db.c atpl360_IB_db.h atpl360_comm.h general_defs.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: queue.c list.c timers.c tasks.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: portable.h queue.h projdefs.h FreeRTOS.h FreeRTOS_CLI.h mpu_wrappers.h StackMacros.h croutine.h list.h task.h semphr.h timers.h
  group thirdparty/prime_ng/hal
    ../../../../../../hal/: hal_aes.c hal_usart.c hal_pib.c hal_reset_handler.c hal_uart.c hal.c hal_fu.c hal_pcrc.c hal_usi.c hal_trng.c hal_cfg.c hal_plc.c hal_null_dev.c conf_timer_1us.h hal_private.h hal_regions.h conf_prf_if.h hal.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: pl460_1_5b_2chn.h pl460_1_5b_chn_fcc.h plcoup007_chn_1.h pl460_sb_chn_fcc.h pl460_plcoup007_chn_1.h pl460_sb_2chn.h pl460_sb_chn_1.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl460
    ../../../../coup_tx_config/coup_conf/pl460/: coup_conf.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/phy_app
    ../../../../coup_tx_config/app_wrp/phy_app/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console
    ../../: phy_embedded_app.c phy_tx_test_console.c phy_embedded_app.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console/pic32cxmtsh_db_pl460
    ../: conf_cl010_slcdc.h conf_app_example.h conf_clock.h conf_sleepmgr.h conf_board.h conf_slcdc.h FreeRTOSConfig.h conf_hal.h conf_atpl360.h conf_uart_serial.h conf_usi.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console/pic32cxmtsh_db_pl460/iar
    ./: asf.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/slcdc
    ../../../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/pio/pic32cx
    ../../../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../../../sam/drivers/pmc/pic32cx/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/dwdt
    ../../../../../../../../sam/drivers/dwdt/: dwdt.c dwdt.h
  group sam/drivers/aes
    ../../../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/services/timer_1us
    ../../../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us.h timer_1us_hal.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/components/display/cl010
    ../../../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010_segmap.h cl010.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx2051mtsh128S1.h pic32cx2051mtg64.h pic32cx1025mtc128S1.h pic32cx1025mtg128.h pic32cx2051mtc128S1.h pic32cx5112mtc128S1.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx1025mtc128.h pic32cx5112mtsh128.h pic32cx1025mtsh128S1.h pic32cx1025mtg64.h pic32cx2051mtc128.h pic32cx5112mtsh128S1.h pic32cx5112mtc128.h pic32cxmt.h system_pic32cxmt.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/component/: gpbr.h mcspi.h rtt.h sfr.h emafe.h supc.h tc.h acc.h ipc.h slcdc.h rstc.h cpkcc.h qspi.h pmc.h trng.h uart.h rtc.h twi.h dwdt.h aes.h pwm.h icm.h adc.h spi.h cmcc.h pio.h mem2mem.h pdc.h aesb.h flexcom.h sha.h usart.h chipid.h syscwp.h matrix.h sefc.h sfrbu.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/instance/: twi0.h flexcom4.h flexcom3.h spi7.h twi7.h ipc1.h cmcc0.h pmc.h twi1.h flexcom2.h twi6.h dwdt.h usart6.h usart7.h rstc.h sefc1.h adc.h flexcom0.h twi4.h twi2.h tc0.h flexcom6.h spi5.h spi4.h ipc0.h trng.h mcspi.h sha.h usart2.h sfr.h spi1.h usart0.h sefc0.h mem2mem0.h sfrbu.h aes.h matrix0.h spi0.h icm.h matrix2.h spi3.h tc2.h pio.h rtc.h slcdc.h cpkcc.h gpbr.h twi5.h usart3.h usart1.h qspi.h emafe.h matrix3.h cmcc1.h flexcom5.h matrix1.h syscwp.h spi2.h tc1.h tc3.h usart5.h supc.h uart.h flexcom1.h acc.h rtt.h pwm.h usart4.h chipid.h aesb.h flexcom7.h twi3.h spi6.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtg64.h pic32cx1025mtc128.h pic32cx2051mtg128.h pic32cx2051mtsh128.h pic32cx1025mtsh128.h pic32cx5112mtc128.h pic32cx5112mtg128.h pic32cx1025mtg128.h pic32cx5112mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg64.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../../../../sam/boards/pic32cxmtsh_db/: init.c pic32cxmtsh_db.h led.h
