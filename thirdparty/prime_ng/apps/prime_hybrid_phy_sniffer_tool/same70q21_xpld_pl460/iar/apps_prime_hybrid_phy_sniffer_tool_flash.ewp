# IAR project apps_prime_hybrid_phy_sniffer_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; UDD_ENABLE; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\boards\same70_xplained; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq; ..\..\..\..\..\..\sam\drivers\uart; ..; ..\..\..\..\pal\include; ..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\prime; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\..\..\common\components\rf\at86rf215\addons; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\pal\mpal; ..\..\..\..\..\..\common\components\rf\at86rf215; ..\..\..\..\..\..\sam\drivers\usbhs; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc; ..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_plcoupxxx; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_hybrid_phy_sniffer_tool_flash.bin
  ILINK.IlinkOutputFile: apps_prime_hybrid_phy_sniffer_tool_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\same70\same70q21\iar\flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME_2CHN.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/rf/at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c ieee_15_4_sun_fsk.h at86rf.h at86rf_defs.h ieee_15_4_sun_ofdm.h at86rf_version.h
  group common/components/rf/at86rf215/rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_trx_ctl.c rf215_spi.c rf215_spi.h rf215_phy_defs.h rf215_trx_ctl.h rf215_reg.h rf215_conf_check.h
  group common/components/rf/at86rf215/rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c rf215_irq.h rf215_irq_defs.h
  group common/components/rf/at86rf215/rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c rf215_bbc.h rf215_bbc_defs.h
  group common/components/rf/at86rf215/rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_tx.c rf215_rx.c rf215_tx_rx_defs.h rf215_tx_rx.h
  group common/components/rf/at86rf215/rf215_pll
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c rf215_pll_defs.h rf215_pll.h
  group common/components/rf/at86rf215/addons
    ../../../../../../common/components/rf/at86rf215/addons/: rf215_addon.h
  group common/components/rf/at86rf215/addons/sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common/components/rf/at86rf215/addons/sniffer_if/prime
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/prime/: rf215_sniffer_if_prime.c rf215_sniffer_if.h
  group common/components/rf/at86rf215/rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c rf215_fe.h rf215_fe_defs.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360.c atpl360_boot.c atpl360_hal_spi.c atpl360_IB.c atpl360_IB.h atpl360.h atpl360_boot.h atpl360_hal_spi.h atpl360_IB_db_api.h atpl360_exception.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_IB_db.c atpl360_IB_db.h atpl360_comm.h general_defs.h
  group common/components/plc/atpl360/addons
    ../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/sniffer_if
    ../../../../../../common/components/plc/atpl360/addons/sniffer_if/: sniffer_if.c sniffer_if_prime.c sniffer_if.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/usbhs
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/afec
    ../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/xdmac
    ../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70j19.h same70j19b.h same70n19.h same70q20b.h same70n20.h same70j20.h same70.h same70n21.h same70q19.h same70q20.h same70j21b.h same70j21.h same70q19b.h same70n21b.h same70n20b.h same70q21b.h same70j20b.h same70n19b.h same70q21.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70j19.h same70n20.h same70q21.h same70j21.h same70n20b.h same70n21.h same70q20.h same70n19.h same70n19b.h same70j20.h same70q19.h same70q19b.h same70j19b.h same70q21b.h same70n21b.h same70j21b.h same70j20b.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: aes.h afec.h spi.h mcan.h utmi.h efc.h gmac.h wdt.h rtc.h xdmac.h uart.h pio.h gpbr.h qspi.h sdramc.h usart.h dacc.h pmc.h rstc.h chipid.h matrix.h twihs.h rtt.h i2sc.h ssc.h usbhs.h rswdt.h supc.h hsmci.h pwm.h smc.h isi.h icm.h tc.h trng.h acc.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: utmi.h tc2.h dacc.h usart1.h pioc.h rtc.h i2sc0.h pioe.h sdramc.h gmac.h trng.h uart3.h matrix.h tc3.h pioa.h xdmac.h isi.h usart0.h efc.h qspi.h tc1.h usart2.h mcan1.h twihs1.h gpbr.h usbhs.h hsmci.h spi0.h pwm1.h chipid.h twihs2.h uart1.h pwm0.h tc0.h icm.h rtt.h uart4.h aes.h twihs0.h afec1.h spi1.h ssc.h acc.h rswdt.h mcan0.h i2sc1.h piob.h uart2.h supc.h piod.h smc.h rstc.h wdt.h afec0.h uart0.h pmc.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_same70
    ../../../../../../sam/services/timer_1us/hal_same70/: timer_1us_hal.c
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/boards/same70_xplained
    ../../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: plcoup011_chn_fcc.h plcoup011_2chn.h plcoup006_2chn.h plcoup007_chn_1.h plcoup006_chn_fcc.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/pal
    ../../../../phy/atpl360/coup_tx_config/app_wrp/pal/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl360_plcoupxxx
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl360_plcoupxxx/: coup_conf.h
  group thirdparty/prime_ng/pal/mpal
    ../../../../pal/mpal/: mpal.c mpal.h
  group thirdparty/prime_ng/pal/rf215_prime/source
    ../../../../pal/rf215_prime/source/: pal_rf.c pal_rf_rm.c pal_rf_rm.h
  group thirdparty/prime_ng/pal/atpl360_prime/source
    ../../../../pal/atpl360_prime/source/: pal_rm.c pal.c pal_rm.h
  group thirdparty/prime_ng/pal/include
    ../../../../pal/include/: pal.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: hal_aes.c hal_reset_handler.c hal_pib.c hal_usb.c hal_fu.c hal_cm7_uart.c hal_cm7_usart.c hal_cm7_plc.c hal.c hal_cfg.c hal_pcrc.c hal_usi.c hal_trng.c hal_null_dev.c hal_private.h hal_regions.h hal.h conf_prf_if.h conf_timer_1us.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_hal_wrapper.c prime_hal_wrapper.h
  group thirdparty/prime_ng/apps/prime_hybrid_phy_sniffer_tool
    ../../: main.c
  group thirdparty/prime_ng/apps/prime_hybrid_phy_sniffer_tool/same70q21_xpld_pl460
    ../: conf_at86rf.h conf_app_example.h conf_clock.h conf_uart_serial.h conf_board.h conf_usb.h conf_usi.h conf_sleepmgr.h conf_pal.h conf_hal.h conf_atpl360.h
  group thirdparty/prime_ng/apps/prime_hybrid_phy_sniffer_tool/same70q21_xpld_pl460/iar
    ./: asf.h
