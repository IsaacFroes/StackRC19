# IAR project apps_prime_service_dual_dlms_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\..\dlms\server\profile_prime; ..\..; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\mac; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\sam\drivers\adc; ..; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\mbed-tls\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_service_dual_dlms_flash.bin
  ILINK.IlinkOutputFile: apps_prime_service_dual_dlms_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\pic32cx_0_flash_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/profile_prime
    ../../../../../dlms/server/profile_prime/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/dlms/server/lib
    ../../../../../dlms/server/lib/: dlms_srv_types.h dlms_srv_cnf.h dlms_srv_lib.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: hal_plc.c hal_fu.c hal_null_dev.c hal_aes.c hal_pib.c hal_trng.c hal_pcrc.c hal_cfg.c hal_usart.c hal_reset_handler.c hal.c hal_uart.c hal_usi.c conf_prf_if.h hal_private.h conf_timer_1us.h hal_regions.h hal.h
  group thirdparty/prime_ng/mbed-tls/library
    ../../../../mbed-tls/library/: sha1.c aesni.c x509_create.c ecp_curves.c camellia.c pkcs11.c ssl_ticket.c pkcs5.c ssl_ciphersuites.c md_wrap.c pem.c pkparse.c mbed_tls_oid.c des.c memory_buffer_alloc.c x509_crt.c error.c certs.c hmac_drbg.c arc4.c pk.c ecp.c asn1parse.c ecdh.c mbed_tls_debug.c threading.c bignum.c asn1write.c ssl_tls.c timing.c blowfish.c ssl_srv.c x509.c platform.c aes_sig.c version.c x509_csr.c md2.c base64.c xtea.c pkwrite.c x509write_csr.c ctr_drbg.c cipher.c pkcs12.c gcm.c padlock.c havege.c md.c mbed_tls_net.c ssl_cookie.c sha512.c pk_wrap.c cipher_wrap.c sha256.c version_features.c ecjpake.c x509write_crt.c dhm.c ssl_cache.c x509_crl.c md4.c rsa.c ccm.c ecdsa.c ripemd160.c md5.c ssl_cli.c entropy.c
  group thirdparty/prime_ng/mbed-tls/include/mbedtls
    ../../../../mbed-tls/include/mbedtls/: pem.h platform.h md2.h hmac_drbg.h ssl_cookie.h entropy.h ssl_ticket.h pkcs12.h base64.h mbed_tls_debug.h ssl_ciphersuites.h asn1.h md5.h gcm.h x509_crl.h threading.h compat-1.3.h aes.h ecdh.h blowfish.h aesni.h dhm.h padlock.h mbed_tls_net.h sha256.h cipher_internal.h x509_csr.h md_internal.h version.h rsa.h mbed_tls_oid.h havege.h camellia.h x509_crt.h pkcs11.h sha1.h md4.h check_config.h ssl_internal.h bn_mul.h ccm.h entropy_poll.h ecp.h ecdsa.h bignum.h xtea.h asn1write.h cipher.h pkcs5.h md.h sha512.h arc4.h config.h ripemd160.h ssl.h timing.h ctr_drbg.h ssl_cache.h pk.h certs.h x509.h error.h memory_buffer_alloc.h pk_internal.h des.h ecjpake.h
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem_service.c modem.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms
    ../../: app_dc.c dlms_app.c main.c app_emu.c app_user_task.c dlms_srv_data.c app_event_manager.c app_dc.h dlms_srv_data.h dlms_app.h app.h app_emu.h app_event_manager.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms/pic32cxmtsh_db_pl460_bootloader
    ../: conf_cl010_slcdc.h conf_oss.h conf_app_example.h conf_clock.h conf_prime_stack.h conf_sleepmgr.h conf_board.h conf_hal.h conf_slcdc.h conf_uart_serial.h conf_usi.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms/pic32cxmtsh_db_pl460_bootloader/iar
    ./: asf.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api_defs.h prime_api.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432_defs.h
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac_defs.h mac_pib.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/dwdt
    ../../../../../../sam/drivers/dwdt/: dwdt.c dwdt.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us.h timer_1us_hal.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010_segmap.h cl010.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../../sam/boards/pic32cxmtsh_db/: init.c led.h pic32cxmtsh_db.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtc128S1.h pic32cx2051mtsh128S1.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx2051mtc128.h system_pic32cxmt.h pic32cx2051mtg64.h pic32cx1025mtg128.h pic32cx5112mtc128S1.h pic32cx2051mtc128S1.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128S1.h pic32cx1025mtc128.h pic32cx5112mtsh128S1.h pic32cx5112mtsh128.h pic32cx5112mtc128.h pic32cxmt.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: flexcom4.h spi7.h twi2.h twi0.h usart3.h pmc.h flexcom2.h cmcc0.h ipc1.h rtc.h twi7.h usart7.h spi5.h dwdt.h flexcom6.h twi4.h mem2mem0.h rstc.h tc0.h trng.h ipc0.h cpkcc.h usart0.h usart6.h sha.h emafe.h sfr.h aes.h usart2.h sfrbu.h twi6.h usart4.h spi3.h matrix0.h spi1.h gpbr.h pio.h slcdc.h flexcom0.h tc2.h usart1.h cmcc1.h qspi.h sefc1.h adc.h flexcom5.h spi2.h matrix3.h syscwp.h twi1.h matrix1.h spi0.h spi4.h twi5.h uart.h supc.h usart5.h acc.h tc3.h flexcom1.h tc1.h aesb.h pwm.h icm.h rtt.h sefc0.h chipid.h matrix2.h spi6.h twi3.h mcspi.h flexcom7.h flexcom3.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: flexcom.h sfr.h rtt.h mem2mem.h qspi.h emafe.h tc.h twi.h supc.h cpkcc.h pmc.h rstc.h slcdc.h ipc.h pdc.h sha.h uart.h trng.h mcspi.h aes.h dwdt.h icm.h pio.h cmcc.h spi.h adc.h sefc.h usart.h chipid.h pwm.h rtc.h aesb.h sfrbu.h acc.h matrix.h gpbr.h syscwp.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtc128.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx5112mtc128.h pic32cx1025mtg64.h pic32cx1025mtg128.h pic32cx2051mtc128.h pic32cx2051mtg64.h pic32cx5112mtsh128.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: pll.h osc.h sysclk.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/pic32cx_gpio
    ../../../../../../common/services/gpio/pic32cx_gpio/: pic32cx_gpio.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360_hal_spi.h atpl360_exception.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: general_defs.h atpl360_comm.h
  group common/boards
    ../../../../../../common/boards/: board.h
