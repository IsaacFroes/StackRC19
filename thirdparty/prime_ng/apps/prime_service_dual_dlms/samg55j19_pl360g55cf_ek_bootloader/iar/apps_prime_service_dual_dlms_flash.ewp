# IAR project apps_prime_service_dual_dlms_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=PL360G55CF_EK; __SAMG55J19__; UDD_ENABLE; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\..\..\sam\drivers\udp; ..\..\..\..\..\dlms\server\profile_prime; ..\..; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\mac; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\..\..\sam\boards\pl360g55cf_ek; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\mbed-tls\include; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\hal; ..\..\..\..\mac\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\dlms\server\lib; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_service_dual_dlms_flash.bin
  ILINK.IlinkOutputFile: apps_prime_service_dual_dlms_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\samg_atpl360_flash_bootloader_isp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/profile_prime
    ../../../../../dlms/server/profile_prime/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/dlms/server/lib
    ../../../../../dlms/server/lib/: dlms_srv_types.h dlms_srv_cnf.h dlms_srv_lib.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: hal_plc.c hal_fu.c hal_null_dev.c hal_aes.c hal_pib.c hal_usb.c hal_trng.c hal_pcrc.c hal_cfg.c hal_usart.c hal_reset_handler.c hal.c hal_uart.c hal_usi.c conf_prf_if.h hal_private.h hal_regions.h conf_timer_1us.h hal.h
  group thirdparty/prime_ng/mbed-tls/library
    ../../../../mbed-tls/library/: sha1.c aesni.c x509_create.c camellia.c pkcs11.c ssl_ticket.c pkcs5.c ssl_ciphersuites.c md_wrap.c pem.c pkparse.c mbed_tls_oid.c des.c memory_buffer_alloc.c x509_crt.c error.c certs.c hmac_drbg.c arc4.c pk.c ecp.c asn1parse.c ecdh.c threading.c mbed_tls_debug.c bignum.c asn1write.c ssl_tls.c timing.c blowfish.c ssl_srv.c x509.c platform.c ecp_curves.c aes_sig.c version.c x509_csr.c md2.c rsa.c base64.c xtea.c cipher.c x509write_csr.c ctr_drbg.c ecdsa.c pkwrite.c pkcs12.c gcm.c padlock.c havege.c md.c mbed_tls_net.c ssl_cookie.c sha512.c pk_wrap.c cipher_wrap.c sha256.c version_features.c ecjpake.c x509write_crt.c dhm.c ssl_cache.c x509_crl.c md4.c ccm.c ripemd160.c md5.c ssl_cli.c entropy.c
  group thirdparty/prime_ng/mbed-tls/include/mbedtls
    ../../../../mbed-tls/include/mbedtls/: hmac_drbg.h ssl_cookie.h md5.h entropy.h md2.h pkcs12.h md4.h camellia.h asn1.h gcm.h ssl_ticket.h x509_crl.h threading.h compat-1.3.h check_config.h ecdh.h blowfish.h aesni.h padlock.h dhm.h aes.h cipher_internal.h x509_csr.h md_internal.h arc4.h sha512.h version.h rsa.h mbed_tls_oid.h ecjpake.h x509_crt.h mbed_tls_net.h pem.h platform.h ssl_internal.h bn_mul.h ccm.h entropy_poll.h ecp.h error.h ecdsa.h bignum.h xtea.h asn1write.h cipher.h certs.h sha1.h pkcs5.h md.h ctr_drbg.h config.h ripemd160.h ssl.h ssl_cache.h pk.h ssl_ciphersuites.h x509.h base64.h memory_buffer_alloc.h havege.h timing.h pk_internal.h mbed_tls_debug.h des.h pkcs11.h sha256.h
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem_service.c modem.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms
    ../../: app_dc.c dlms_app.c main.c app_emu.c app_user_task.c dlms_srv_data.c app_event_manager.c app_dc.h dlms_app.h app_emu.h dlms_srv_data.h app.h app_event_manager.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms/samg55j19_pl360g55cf_ek_bootloader
    ../: conf_sleepmgr.h conf_oss.h conf_app_example.h conf_clock.h conf_prime_stack.h conf_usb.h conf_board.h conf_hal.h conf_uart_serial.h conf_usi.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms/samg55j19_pl360g55cf_ek_bootloader/iar
    ./: asf.h
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac_pib.h mac_defs.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.h prime_api_defs.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432_defs.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/udp
    ../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us.h timer_1us_hal.h
  group sam/services/timer_1us/hal_samg55
    ../../../../../../sam/services/timer_1us/hal_samg55/: timer_1us_hal.c
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55.h system_samg55.h samg55j19.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: pmc.h rtc.h pdmic1.h usart2.h crccu.h twi3.h usart0.h twi5.h udp.h usart7.h flexcom6.h wdt.h cmcc.h uhp.h supc.h usart3.h i2sc0.h piob.h spi1.h efc.h spi5.h twi6.h spi7.h twi7.h flexcom7.h rtt.h flexcom5.h mem2mem.h tc0.h rstc.h spi4.h twi1.h spi3.h usart5.h i2sc1.h chipid.h flexcom0.h flexcom3.h flexcom1.h tc1.h flexcom4.h pdmic0.h twi2.h twi0.h spi0.h pioa.h spi2.h adc.h spi6.h usart6.h usart1.h usart4.h gpbr.h flexcom2.h matrix.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h pmc.h supc.h matrix.h efc.h cmcc.h flexcom.h rtc.h adc.h rstc.h i2sc.h crccu.h pio.h pdmic.h mem2mem.h udp.h pdc.h gpbr.h usart.h spi.h rtt.h chipid.h twi.h tc.h wdt.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c led.h pl360g55cf_ek.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360_exception.h atpl360_hal_spi.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.h general_defs.h
  group common/boards
    ../../../../../../common/boards/: board.h
