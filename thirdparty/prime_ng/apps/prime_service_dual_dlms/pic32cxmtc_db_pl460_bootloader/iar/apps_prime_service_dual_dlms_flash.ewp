# IAR project apps_prime_service_dual_dlms_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD=PIC32CXMTC_DB; ARM_MATH_CM4=true; __PIC32CX2051MTC128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..\..\..\..\dlms\server\profile_prime; ..\..; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\mac; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\sam\drivers\adc; ..; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\mbed-tls\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\usart; .; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\dlms\server\profile_prime; C:\Users\Isaac\OneDrive\Workspace\Edge Prime\Codes\Stack140401RC19)\thirdparty\prime_ng\pal\include; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\mac; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\sam\drivers\adc; ..; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\mbed-tls\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\usart; .; ..\..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460; ..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..
  AARM.PreInclude: C:\Users\Isaac\OneDrive\Workspace\Edge Prime\Codes\Stack140401RC19)\thirdparty\prime_ng\pal\include\pal.h
  OBJCOPY.OOCOutputFile: apps_prime_service_dual_dlms_flash.bin
  ILINK.IlinkOutputFile: apps_prime_service_dual_dlms_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\pic32cx_0_flash_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 0
  ICCARM.CCDefines: BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\..\dlms\server\profile_prime; ..\..; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\mac; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\sam\drivers\adc; ..; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\mbed-tls\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\usart; .
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  group common/boards
    ../../../../../../common/boards/: board.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360_exception.h atpl360_hal_spi.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.h general_defs.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: genclk.h osc.h pll.h sysclk.c sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/pic32cx_gpio
    ../../../../../../common/services/gpio/pic32cx_gpio/: pic32cx_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h usart_serial.c
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../../sam/boards/pic32cxmtsh_db/: init.c led.h pic32cxmtsh_db.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010.h cl010_font.h cl010_segmap.h cl010_slcdc.c
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/drivers/dwdt
    ../../../../../../sam/drivers/dwdt/: dwdt.c dwdt.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio.c pio.h pio_handler.c pio_handler.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: pmc.c pmc.h sleep.c sleep.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us.h timer_1us_hal.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtc128.h pic32cx1025mtc128S1.h pic32cx1025mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128.h pic32cx1025mtsh128S1.h pic32cx2051mtc128.h pic32cx2051mtc128S1.h pic32cx2051mtg128.h pic32cx2051mtg64.h pic32cx2051mtsh128.h pic32cx2051mtsh128S1.h pic32cx5112mtc128.h pic32cx5112mtc128S1.h pic32cx5112mtg128.h pic32cx5112mtsh128.h pic32cx5112mtsh128S1.h pic32cxmt.h system_pic32cxmt.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: acc.h adc.h aes.h aesb.h chipid.h cmcc.h cpkcc.h dwdt.h emafe.h flexcom.h gpbr.h icm.h ipc.h matrix.h mcspi.h mem2mem.h pdc.h pio.h pmc.h pwm.h qspi.h rstc.h rtc.h rtt.h sefc.h sfr.h sfrbu.h sha.h slcdc.h spi.h supc.h syscwp.h tc.h trng.h twi.h uart.h usart.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: acc.h adc.h aes.h aesb.h chipid.h cmcc0.h cmcc1.h cpkcc.h dwdt.h emafe.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h gpbr.h icm.h ipc0.h ipc1.h matrix0.h matrix1.h matrix2.h matrix3.h mcspi.h mem2mem0.h mem2mem1.h pio.h pmc.h pwm.h qspi.h rstc.h rtc.h rtt.h sefc0.h sefc1.h sfr.h sfrbu.h sha.h slcdc.h spi0.h spi1.h spi2.h spi3.h spi4.h spi5.h spi6.h spi7.h supc.h syscwp.h tc0.h tc1.h tc2.h tc3.h trng.h twi0.h twi1.h twi2.h twi3.h twi4.h twi5.h twi6.h twi7.h uart.h usart0.h usart1.h usart2.h usart3.h usart4.h usart5.h usart6.h usart7.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtc128.h pic32cx1025mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg128.h pic32cx2051mtg64.h pic32cx2051mtsh128.h pic32cx5112mtc128.h pic32cx5112mtg128.h pic32cx5112mtsh128.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/lib
    ../../../../../dlms/server/lib/: dlms_srv_cnf.h dlms_srv_lib.h dlms_srv_types.h
  group thirdparty/dlms/server/profile_prime
    ../../../../../dlms/server/profile_prime/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem.h modem_service.c
  group thirdparty/prime_ng/apps/prime_service_dual_dlms
    ../../: app.h app_dc.c app_dc.h app_emu.c app_emu.h app_event_manager.c app_event_manager.h app_user_task.c dlms_app.c dlms_app.h dlms_srv_data.c dlms_srv_data.h main.c
  group thirdparty/prime_ng/apps/prime_service_dual_dlms/pic32cxmtsh_db_pl460_bootloader
    ../: conf_app_example.h conf_board.h conf_cl010_slcdc.h conf_clock.h conf_hal.h conf_oss.h conf_prime_stack.h conf_slcdc.h conf_sleepmgr.h conf_uart_serial.h conf_usi.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms/pic32cxmtsh_db_pl460_bootloader/iar
    ./: asf.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432_defs.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: conf_prf_if.h conf_timer_1us.h hal.c hal.h hal_aes.c hal_cfg.c hal_fu.c hal_null_dev.c hal_pcrc.c hal_pib.c hal_plc.c hal_private.h hal_regions.h hal_reset_handler.c hal_trng.c hal_uart.c hal_usart.c hal_usi.c
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac_defs.h mac_pib.h
  group thirdparty/prime_ng/mbed-tls/include/mbedtls
    ../../../../mbed-tls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h mbed_tls_debug.h mbed_tls_net.h mbed_tls_oid.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group thirdparty/prime_ng/mbed-tls/library
    ../../../../mbed-tls/library/: aes_sig.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c error.c gcm.c havege.c hmac_drbg.c mbed_tls_debug.c mbed_tls_net.c mbed_tls_oid.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.h prime_api_defs.h
