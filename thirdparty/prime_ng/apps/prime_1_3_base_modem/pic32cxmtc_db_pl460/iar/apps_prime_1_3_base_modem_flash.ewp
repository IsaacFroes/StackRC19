# IAR project apps_prime_1_3_base_modem_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FREERTOS__; BOARD=PIC32CXMTC_DB; ARM_MATH_CM4=true; __PIC32CX2051MTC128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..\..\..\..\..\common\boards; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\mac; ..\..\..\..\pal\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mngp; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\common\services\gpio; ..; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\utils; ..\..\..\..\mac\include; ..\..; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_1_3_base_modem_flash.bin
  ILINK.IlinkOutputFile: apps_prime_1_3_base_modem_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\pic32cx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 0
  ICCARM.CCDefines: __FREERTOS__; BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\..\..\common\boards; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\mac; ..\..\..\..\pal\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mngp; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\common\services\gpio; ..; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\utils; ..\..\..\..\mac\include; ..\..; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\sam\drivers\rstc; .
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  group common/boards
    ../../../../../../common/boards/: board.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360.c atpl360.h atpl360_boot.c atpl360_boot.h atpl360_exception.h atpl360_hal_spi.c atpl360_hal_spi.h atpl360_IB.c atpl360_IB.h atpl360_IB_db_api.h
  group common/components/plc/atpl360/addons
    ../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/sniffer_if
    ../../../../../../common/components/plc/atpl360/addons/sniffer_if/: sniffer_if.c sniffer_if.h sniffer_if_prime.c
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_comm.h atpl360_IB_db.c atpl360_IB_db.h general_defs.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: genclk.h osc.h pll.h sysclk.c sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/pic32cx_gpio
    ../../../../../../common/services/gpio/pic32cx_gpio/: pic32cx_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h usart_serial.c
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../../sam/boards/pic32cxmtsh_db/: init.c led.h pic32cxmtsh_db.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010.h cl010_font.h cl010_segmap.h cl010_slcdc.c
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/drivers/dwdt
    ../../../../../../sam/drivers/dwdt/: dwdt.c dwdt.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio.c pio.h pio_handler.c pio_handler.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: pmc.c pmc.h sleep.c sleep.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us.h timer_1us_hal.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtc128.h pic32cx1025mtc128S1.h pic32cx1025mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128.h pic32cx1025mtsh128S1.h pic32cx2051mtc128.h pic32cx2051mtc128S1.h pic32cx2051mtg128.h pic32cx2051mtg64.h pic32cx2051mtsh128.h pic32cx2051mtsh128S1.h pic32cx5112mtc128.h pic32cx5112mtc128S1.h pic32cx5112mtg128.h pic32cx5112mtsh128.h pic32cx5112mtsh128S1.h pic32cxmt.h system_pic32cxmt.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: acc.h adc.h aes.h aesb.h chipid.h cmcc.h cpkcc.h dwdt.h emafe.h flexcom.h gpbr.h icm.h ipc.h matrix.h mcspi.h mem2mem.h pdc.h pio.h pmc.h pwm.h qspi.h rstc.h rtc.h rtt.h sefc.h sfr.h sfrbu.h sha.h slcdc.h spi.h supc.h syscwp.h tc.h trng.h twi.h uart.h usart.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: acc.h adc.h aes.h aesb.h chipid.h cmcc0.h cmcc1.h cpkcc.h dwdt.h emafe.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h gpbr.h icm.h ipc0.h ipc1.h matrix0.h matrix1.h matrix2.h matrix3.h mcspi.h mem2mem0.h mem2mem1.h pio.h pmc.h pwm.h qspi.h rstc.h rtc.h rtt.h sefc0.h sefc1.h sfr.h sfrbu.h sha.h slcdc.h spi0.h spi1.h spi2.h spi3.h spi4.h spi5.h spi6.h spi7.h supc.h syscwp.h tc0.h tc1.h tc2.h tc3.h trng.h twi0.h twi1.h twi2.h twi3.h twi4.h twi5.h twi6.h twi7.h uart.h usart0.h usart1.h usart2.h usart3.h usart4.h usart5.h usart6.h usart7.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtc128.h pic32cx1025mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg128.h pic32cx2051mtg64.h pic32cx2051mtsh128.h pic32cx5112mtc128.h pic32cx5112mtg128.h pic32cx5112mtsh128.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: FreeRTOS_CLI.c list.c queue.c tasks.c timers.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: croutine.h FreeRTOS.h FreeRTOS_CLI.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem.h modem_base.c modem_base_task.c
  group thirdparty/prime_ng/apps/prime_1_3_base_modem
    ../../: app.h main.c prime_task.c user_task.c
  group thirdparty/prime_ng/apps/prime_1_3_base_modem/pic32cxmtsh_db_pl460
    ../: conf_app_example.h conf_atpl360.h conf_board.h conf_cl010_slcdc.h conf_clock.h conf_hal.h conf_mac.h conf_mngp.h conf_oss.h conf_pal.h conf_prime_stack.h conf_slcdc.h conf_sleepmgr.h conf_uart_serial.h conf_usi.h FreeRTOSConfig.h
  group thirdparty/prime_ng/apps/prime_1_3_base_modem/pic32cxmtsh_db_pl460/iar
    ./: asf.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432.h cl_432_api.h cl_432_defs.h
  group thirdparty/prime_ng/conv/sscs/null
    ../../../../conv/sscs/null/: cl_null.h cl_null_api.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: conf_prf_if.h conf_timer_1us.h hal.c hal.h hal_aes.c hal_cfg.c hal_fu.c hal_null_dev.c hal_pcrc.c hal_pib.c hal_plc.c hal_private.h hal_regions.h hal_reset_handler.c hal_trng.c hal_uart.c hal_usart.c hal_usi.c
  group thirdparty/prime_ng/libs/iar
    ../../../../libs/iar/: libsamM4-prime13-bn_m-iar.a
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac.h mac_defs.h mac_pib.h
  group thirdparty/prime_ng/mngp
    ../../../../mngp/: bmng_api.h bmng_defs.h mngp.h
  group thirdparty/prime_ng/pal/atpl360_prime/source
    ../../../../pal/atpl360_prime/source/: pal.c pal_rm.c pal_rm.h
  group thirdparty/prime_ng/pal/include
    ../../../../pal/include/: pal.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/pal
    ../../../../phy/atpl360/coup_tx_config/app_wrp/pal/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl460
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460/: coup_conf.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_2chn.h pl460_1_5b_chn_fcc.h pl460_plcoup007_chn_1.h pl460_sb_2chn.h pl460_sb_chn_1.h pl460_sb_chn_fcc.h plcoup007_chn_1.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.c prime_api.h prime_api_defs.h prime_hal_wrapper.c prime_hal_wrapper.h
