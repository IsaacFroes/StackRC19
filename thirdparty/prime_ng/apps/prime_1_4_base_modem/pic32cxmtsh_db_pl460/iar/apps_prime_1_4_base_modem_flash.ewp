# IAR project apps_prime_1_4_base_modem_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FREERTOS__; BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\services\ioport; ..; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\..\..\common\boards; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\mac; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll; ..\..\..\..\pal\include; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq; ..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\prime; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\..\..\common\components\rf\at86rf215\addons; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\mngp; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\pal\mpal; ..\..\..\..\..\..\common\components\rf\at86rf215; ..\..\..\..\..\..\sam\drivers\dwdt; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\modem; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_1_4_base_modem_flash.bin
  ILINK.IlinkOutputFile: apps_prime_1_4_base_modem_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\pic32cx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME_2CHN.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group thirdparty/prime_ng/libs/iar
    ../../../../libs/iar/: libsamM4-prime14-bn_m-iar.a
  group thirdparty/prime_ng/hal
    ../../../../hal/: hal_plc.c hal_fu.c hal_null_dev.c hal_aes.c hal_pib.c hal_trng.c hal_pcrc.c hal_cfg.c hal_usart.c hal_reset_handler.c hal.c hal_uart.c hal_usi.c hal_private.h hal_regions.h hal.h conf_prf_if.h conf_timer_1us.h
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem_base_task.c modem_base.c modem.h
  group thirdparty/prime_ng/apps/prime_1_4_base_modem
    ../../: main.c user_task.c prime_task.c app.h
  group thirdparty/prime_ng/apps/prime_1_4_base_modem/pic32cxmtsh_db_pl460
    ../: conf_at86rf.h conf_cl010_slcdc.h conf_oss.h conf_app_example.h conf_clock.h conf_atpl360.h conf_slcdc.h conf_usi.h conf_sleepmgr.h conf_prime_stack.h conf_board.h conf_pal.h FreeRTOSConfig.h conf_hal.h conf_mac.h conf_uart_serial.h conf_mngp.h
  group thirdparty/prime_ng/apps/prime_1_4_base_modem/pic32cxmtsh_db_pl460/iar
    ./: asf.h
  group thirdparty/prime_ng/pal/atpl360_prime/source
    ../../../../pal/atpl360_prime/source/: pal.c pal_rm.c pal_rm.h
  group thirdparty/prime_ng/pal/rf215_prime/source
    ../../../../pal/rf215_prime/source/: pal_rf.c pal_rf_rm.c pal_rf_rm.h
  group thirdparty/prime_ng/pal/mpal
    ../../../../pal/mpal/: mpal.c mpal.h
  group thirdparty/prime_ng/pal/include
    ../../../../pal/include/: pal.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.c prime_hal_wrapper.c prime_api.h prime_api_defs.h prime_hal_wrapper.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl460
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460/: coup_conf.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_chn_fcc.h plcoup007_chn_1.h pl460_sb_2chn.h pl460_sb_chn_1.h pl460_sb_chn_fcc.h pl460_1_5b_2chn.h pl460_plcoup007_chn_1.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/pal
    ../../../../phy/atpl360/coup_tx_config/app_wrp/pal/: coup_app_wrp.h
  group thirdparty/prime_ng/mngp
    ../../../../mngp/: bmng_api.h mngp.h bmng_defs.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432_defs.h cl_432_api.h cl_432.h
  group thirdparty/prime_ng/conv/sscs/null
    ../../../../conv/sscs/null/: cl_null_api.h cl_null.h
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac_defs.h mac.h mac_pib.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c queue.c list.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h FreeRTOS.h mpu_wrappers.h list.h croutine.h FreeRTOS_CLI.h projdefs.h timers.h StackMacros.h queue.h task.h semphr.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/dwdt
    ../../../../../../sam/drivers/dwdt/: dwdt.c dwdt.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010_segmap.h cl010.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../../sam/boards/pic32cxmtsh_db/: init.c led.h pic32cxmtsh_db.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtc128S1.h pic32cx2051mtsh128S1.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg64.h pic32cx1025mtg128.h pic32cx5112mtc128S1.h pic32cx2051mtc128S1.h pic32cx2051mtsh128.h pic32cx1025mtg64.h pic32cx1025mtsh128S1.h pic32cx1025mtc128.h pic32cx5112mtsh128S1.h system_pic32cxmt.h pic32cx5112mtsh128.h pic32cx5112mtc128.h pic32cxmt.h pic32cx2051mtg128.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: flexcom4.h usart5.h twi2.h twi0.h pmc.h flexcom2.h cmcc0.h ipc1.h twi7.h usart7.h spi5.h flexcom0.h dwdt.h flexcom6.h twi4.h mem2mem0.h spi4.h spi7.h rstc.h tc0.h trng.h ipc0.h cpkcc.h usart0.h usart6.h sha.h aes.h usart4.h usart2.h sfrbu.h sefc0.h twi6.h spi3.h matrix0.h spi1.h gpbr.h pio.h slcdc.h tc2.h rtc.h usart3.h cmcc1.h emafe.h acc.h qspi.h sefc1.h adc.h flexcom5.h spi2.h matrix3.h syscwp.h twi1.h matrix1.h spi0.h twi5.h supc.h sfr.h tc3.h flexcom1.h tc1.h aesb.h pwm.h icm.h rtt.h usart1.h uart.h chipid.h matrix2.h spi6.h twi3.h mcspi.h flexcom7.h flexcom3.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx5112mtc128.h pic32cx2051mtc128.h pic32cx5112mtsh128.h pic32cx1025mtc128.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx1025mtg64.h pic32cx1025mtg128.h pic32cx2051mtg64.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: twi.h sfr.h rtt.h mem2mem.h mcspi.h cpkcc.h emafe.h tc.h pmc.h rstc.h slcdc.h ipc.h pdc.h acc.h uart.h trng.h aes.h dwdt.h rtc.h qspi.h icm.h matrix.h supc.h pio.h cmcc.h spi.h adc.h chipid.h sefc.h pwm.h sha.h aesb.h sfrbu.h syscwp.h gpbr.h usart.h flexcom.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group common/components/rf/at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c ieee_15_4_sun_fsk.h at86rf.h ieee_15_4_sun_ofdm.h at86rf_defs.h at86rf_version.h
  group common/components/rf/at86rf215/rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c rf215_irq.h rf215_irq_defs.h
  group common/components/rf/at86rf215/rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c rf215_spi.h rf215_phy_defs.h rf215_trx_ctl.h rf215_reg.h rf215_conf_check.h
  group common/components/rf/at86rf215/rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c rf215_tx_rx_defs.h rf215_tx_rx.h
  group common/components/rf/at86rf215/rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c rf215_bbc.h rf215_bbc_defs.h
  group common/components/rf/at86rf215/rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c rf215_fe.h rf215_fe_defs.h
  group common/components/rf/at86rf215/rf215_pll
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c rf215_pll_defs.h rf215_pll.h
  group common/components/rf/at86rf215/addons
    ../../../../../../common/components/rf/at86rf215/addons/: rf215_addon.h
  group common/components/rf/at86rf215/addons/sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common/components/rf/at86rf215/addons/sniffer_if/prime
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/prime/: rf215_sniffer_if_prime.c rf215_sniffer_if.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360_IB.c atpl360_hal_spi.c atpl360.c atpl360_boot.h atpl360_IB.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_IB_db.c atpl360_comm.c atpl360_IB_db.h general_defs.h atpl360_comm.h
  group common/components/plc/atpl360/addons
    ../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/sniffer_if
    ../../../../../../common/components/plc/atpl360/addons/sniffer_if/: sniffer_if.c sniffer_if_prime.c sniffer_if.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/pic32cx_gpio
    ../../../../../../common/services/gpio/pic32cx_gpio/: pic32cx_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
