<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_prime_1_4_base_modem_flash.ewp</path>
	</project>
</workspace>
