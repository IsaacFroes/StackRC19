# IAR project apps_prime_1_4_base_modem_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; __SAMG55J19__; UDD_ENABLE; ARM_MATH_CM4=true; BOARD=SAMG55_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\common\components\rf\at86rf215\addons; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\..\..\sam\drivers\udp; ..\..\..\..\..\..\common\boards; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq; ..\..\..\..\mac; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll; ..\..\..\..\pal\include; ..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\prime; ..\..\..\..\..\..\sam\drivers\pmc; ..\..; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mngp; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\boards\samg55_xplained_pro; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\common\components\rf\at86rf215; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\mbed-tls\include; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\hal; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\pal\mpal; ..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\modem; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_1_4_base_modem_flash.bin
  ILINK.IlinkOutputFile: apps_prime_1_4_base_modem_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\samg\samg55j19\iar\flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME_2CHN.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime_ng/libs/iar
    ../../../../libs/iar/: libsamM4-prime14-bn_xs-iar.a
  group thirdparty/prime_ng/hal
    ../../../../hal/: hal_plc.c hal_fu.c hal_null_dev.c hal_aes.c hal_pib.c hal_usb.c hal_trng.c hal_pcrc.c hal_cfg.c hal_usart.c hal_reset_handler.c hal.c hal_uart.c hal_usi.c hal.h hal_private.h hal_regions.h conf_timer_1us.h conf_prf_if.h
  group thirdparty/prime_ng/mbed-tls/library
    ../../../../mbed-tls/library/: ssl_ciphersuites.c sha1.c aesni.c x509_create.c camellia.c pkcs11.c ssl_ticket.c pkcs5.c md_wrap.c pem.c pkparse.c mbed_tls_oid.c des.c memory_buffer_alloc.c x509_crt.c error.c certs.c hmac_drbg.c pk.c ecp.c asn1parse.c ecdh.c threading.c mbed_tls_debug.c bignum.c asn1write.c ssl_tls.c mbed_tls_net.c blowfish.c ccm.c ssl_srv.c x509.c platform.c ecp_curves.c aes_sig.c version.c x509_csr.c md2.c base64.c xtea.c cipher.c x509write_csr.c ctr_drbg.c ecdsa.c pkwrite.c pkcs12.c gcm.c padlock.c havege.c md.c timing.c ssl_cookie.c sha512.c pk_wrap.c cipher_wrap.c sha256.c version_features.c ecjpake.c x509write_crt.c dhm.c ssl_cache.c x509_crl.c md4.c rsa.c arc4.c ripemd160.c md5.c ssl_cli.c entropy.c
  group thirdparty/prime_ng/mbed-tls/include/mbedtls
    ../../../../mbed-tls/include/mbedtls/: x509.h hmac_drbg.h asn1write.h md5.h entropy.h md2.h pkcs12.h ssl_cache.h md4.h camellia.h asn1.h gcm.h ssl_cookie.h ssl_ticket.h x509_crl.h threading.h compat-1.3.h pkcs5.h ecdh.h blowfish.h aesni.h padlock.h dhm.h aes.h check_config.h cipher_internal.h pem.h rsa.h md_internal.h havege.h sha512.h version.h base64.h x509_csr.h mbed_tls_oid.h ecjpake.h x509_crt.h mbed_tls_net.h bn_mul.h platform.h ssl_internal.h ccm.h entropy_poll.h ecdsa.h timing.h xtea.h cipher.h certs.h sha1.h md.h arc4.h ecp.h config.h ripemd160.h ssl.h error.h ctr_drbg.h pk.h ssl_ciphersuites.h memory_buffer_alloc.h bignum.h pk_internal.h mbed_tls_debug.h des.h pkcs11.h sha256.h
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem_base_task.c modem_base.c modem.h
  group thirdparty/prime_ng/apps/prime_1_4_base_modem
    ../../: main.c user_task.c prime_task.c app.h
  group thirdparty/prime_ng/apps/prime_1_4_base_modem/samg55j19_xplained_pl460
    ../: conf_at86rf.h conf_oss.h conf_app_example.h conf_clock.h conf_board.h conf_usb.h conf_prime_stack.h conf_sleepmgr.h FreeRTOSConfig.h conf_pal.h conf_hal.h conf_mac.h conf_atpl360.h conf_uart_serial.h conf_mngp.h conf_usi.h
  group thirdparty/prime_ng/apps/prime_1_4_base_modem/samg55j19_xplained_pl460/iar
    ./: asf.h
  group thirdparty/prime_ng/pal/atpl360_prime/source
    ../../../../pal/atpl360_prime/source/: pal.c pal_rm.c pal_rm.h
  group thirdparty/prime_ng/pal/rf215_prime/source
    ../../../../pal/rf215_prime/source/: pal_rf.c pal_rf_rm.c pal_rf_rm.h
  group thirdparty/prime_ng/pal/mpal
    ../../../../pal/mpal/: mpal.c mpal.h
  group thirdparty/prime_ng/pal/include
    ../../../../pal/include/: pal.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.c prime_hal_wrapper.c prime_hal_wrapper.h prime_api.h prime_api_defs.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_chn_fcc.h pl460_sb_chn_1.h plcoup007_chn_1.h pl460_sb_2chn.h pl460_sb_chn_fcc.h pl460_plcoup007_chn_1.h pl460_1_5b_2chn.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/pal
    ../../../../phy/atpl360/coup_tx_config/app_wrp/pal/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl460
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460/: coup_conf.h
  group thirdparty/prime_ng/mngp
    ../../../../mngp/: bmng_api.h mngp.h bmng_defs.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432_defs.h cl_432_api.h cl_432.h
  group thirdparty/prime_ng/conv/sscs/null
    ../../../../conv/sscs/null/: cl_null_api.h cl_null.h
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac_pib.h mac_defs.h mac.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c queue.c list.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h FreeRTOS.h task.h mpu_wrappers.h croutine.h queue.h FreeRTOS_CLI.h timers.h StackMacros.h list.h semphr.h
  group common/components/rf/at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c ieee_15_4_sun_fsk.h at86rf.h at86rf_version.h ieee_15_4_sun_ofdm.h at86rf_defs.h
  group common/components/rf/at86rf215/rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c rf215_irq.h rf215_irq_defs.h
  group common/components/rf/at86rf215/rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_tx.c rf215_rx.c rf215_tx_rx_defs.h rf215_tx_rx.h
  group common/components/rf/at86rf215/rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c rf215_trx_ctl.h rf215_spi.h rf215_phy_defs.h rf215_conf_check.h rf215_reg.h
  group common/components/rf/at86rf215/rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c rf215_bbc.h rf215_bbc_defs.h
  group common/components/rf/at86rf215/rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c rf215_fe.h rf215_fe_defs.h
  group common/components/rf/at86rf215/rf215_pll
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c rf215_pll.h rf215_pll_defs.h
  group common/components/rf/at86rf215/addons
    ../../../../../../common/components/rf/at86rf215/addons/: rf215_addon.h
  group common/components/rf/at86rf215/addons/sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common/components/rf/at86rf215/addons/sniffer_if/prime
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/prime/: rf215_sniffer_if_prime.c rf215_sniffer_if.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c atpl360_IB.c atpl360_hal_spi.c atpl360_boot.h atpl360_IB_db_api.h atpl360_IB.h atpl360_hal_spi.h atpl360.h atpl360_exception.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_IB_db.c atpl360_comm.c atpl360_IB_db.h atpl360_comm.h general_defs.h
  group common/components/plc/atpl360/addons
    ../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/sniffer_if
    ../../../../../../common/components/plc/atpl360/addons/sniffer_if/: sniffer_if.c sniffer_if_prime.c sniffer_if.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/udp
    ../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_samg55
    ../../../../../../sam/services/timer_1us/hal_samg55/: timer_1us_hal.c
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55.h system_samg55.h samg55j19.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: pmc.h rtc.h pdmic1.h usart2.h usart0.h twi5.h twi3.h udp.h usart7.h rstc.h flexcom6.h wdt.h cmcc.h uhp.h supc.h usart5.h usart3.h i2sc0.h piob.h spi5.h twi7.h flexcom7.h rtt.h flexcom5.h mem2mem.h matrix.h tc0.h spi7.h spi1.h twi1.h spi3.h twi6.h i2sc1.h efc.h chipid.h flexcom0.h gpbr.h spi4.h flexcom3.h flexcom1.h tc1.h flexcom4.h pdmic0.h twi2.h twi0.h spi0.h pioa.h spi2.h adc.h spi6.h usart6.h usart1.h usart4.h flexcom2.h crccu.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h pmc.h supc.h matrix.h rtc.h cmcc.h rstc.h flexcom.h adc.h i2sc.h efc.h crccu.h pio.h pdmic.h mem2mem.h udp.h pdc.h gpbr.h usart.h spi.h rtt.h chipid.h twi.h tc.h wdt.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../sam/boards/samg55_xplained_pro/: board_init.c samg55_xplained_pro.h led.h
