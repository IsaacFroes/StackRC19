<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_prime_service_dual_modem_flash.ewp</path>
	</project>
</workspace>
