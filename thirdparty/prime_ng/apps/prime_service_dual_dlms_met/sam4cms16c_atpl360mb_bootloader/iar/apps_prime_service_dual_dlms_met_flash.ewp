# IAR project apps_prime_service_dual_dlms_met_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\sam\drivers\rtc; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\sam\components\display\c0216CiZ; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\dlms\server\profile_prime; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\mac; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\services\twi; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\mbed-tls\include; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\services\clock; ..\..; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\drivers\ipc; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\sam\drivers\twi; ..; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include; ..\..\..\..\..\metrology\meter_utils\v_1_43; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\modem; ..\..\..\..\..\..\sam\boards\atpl360mb; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_service_dual_dlms_met_flash.bin
  ILINK.IlinkOutputFile: apps_prime_service_dual_dlms_met_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\sam4c_atpl360_bootloader.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\metrology\meter_utils\v_1_43\core1_binary\Metrology_C1_S.bin,met_bin_start,P_met_bin_start,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/profile_prime
    ../../../../../dlms/server/profile_prime/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/dlms/server/lib
    ../../../../../dlms/server/lib/: dlms_srv_cnf.h dlms_srv_lib.h dlms_srv_types.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: hal_plc.c hal_fu.c hal_null_dev.c hal_at45db32.c hal_aes.c hal_pib.c hal_trng.c hal_pcrc.c hal_cfg.c hal_usart.c hal_reset_handler.c hal.c hal_uart.c hal_usi.c hal_private.h conf_timer_1us.h hal_regions.h hal.h conf_prf_if.h
  group thirdparty/prime_ng/mbed-tls/library
    ../../../../mbed-tls/library/: sha1.c aesni.c x509_create.c camellia.c pkcs11.c ssl_ticket.c pkcs5.c ssl_ciphersuites.c md_wrap.c pem.c pkparse.c mbed_tls_oid.c des.c memory_buffer_alloc.c x509_crt.c error.c certs.c hmac_drbg.c arc4.c pk.c ecp.c asn1parse.c ecdh.c mbed_tls_debug.c threading.c bignum.c asn1write.c ssl_tls.c x509_crl.c timing.c blowfish.c ssl_srv.c x509.c platform.c ecp_curves.c aes_sig.c version.c x509_csr.c md2.c rsa.c base64.c xtea.c pkwrite.c x509write_csr.c ctr_drbg.c ecdsa.c cipher.c pkcs12.c gcm.c padlock.c havege.c md.c mbed_tls_net.c ssl_cookie.c sha512.c pk_wrap.c cipher_wrap.c sha256.c version_features.c ecjpake.c x509write_crt.c dhm.c ssl_cache.c md4.c ccm.c ripemd160.c md5.c ssl_cli.c entropy.c
  group thirdparty/prime_ng/mbed-tls/include/mbedtls
    ../../../../mbed-tls/include/mbedtls/: hmac_drbg.h pkcs11.h md5.h entropy.h ssl_ticket.h cipher.h md2.h certs.h pkcs12.h md4.h camellia.h mbed_tls_debug.h ssl_ciphersuites.h asn1.h gcm.h ssl_cookie.h x509_crl.h threading.h compat-1.3.h check_config.h pkcs5.h ecdh.h blowfish.h aesni.h x509.h padlock.h aes.h cipher_internal.h x509_csr.h md_internal.h arc4.h sha512.h version.h rsa.h mbed_tls_oid.h havege.h ecjpake.h x509_crt.h mbed_tls_net.h pem.h platform.h ssl_internal.h bn_mul.h ccm.h entropy_poll.h ecp.h error.h ecdsa.h bignum.h xtea.h asn1write.h sha1.h md.h ctr_drbg.h config.h ripemd160.h ssl.h dhm.h ssl_cache.h pk.h base64.h memory_buffer_alloc.h timing.h pk_internal.h des.h sha256.h
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem_service.c modem.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms_met
    ../../: app_dc.c metering_task.c dlms_app.c main.c app_emu.c app_user_task.c dlms_srv_data.c app_event_manager.c app.h app_dc.h metering_task.h dlms_app.h app_emu.h app_event_manager.h dlms_srv_data.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms_met/sam4cms16c_atpl360mb_bootloader
    ../: conf_oss.h conf_app_example.h conf_clock.h conf_prime_stack.h conf_sleepmgr.h conf_c0216CiZ.h conf_board.h conf_hal.h conf_platform.h conf_uart_serial.h conf_usi.h
  group thirdparty/prime_ng/apps/prime_service_dual_dlms_met/sam4cms16c_atpl360mb_bootloader/iar
    ./: asf.h
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac_pib.h mac_defs.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.h prime_api_defs.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432_defs.h
  group thirdparty/metrology/meter_utils/v_1_43
    ../../../../../metrology/meter_utils/v_1_43/: shared_memory.c metrology.c rtcproc.c met_utils.c shared_memory.h rtcproc.h met_utils.h metrology.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_1.h sam4cmp16c_0.h sam4cms4c_1.h sam4cms4c_0.h sam4cms8c_0.h system_sam4cm.h sam4cm.h sam4cmp16c_1.h sam4cmp8c_0.h sam4cmp8c_1.h sam4cms16c_1.h sam4cms16c_0.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../sam/utils/cmsis/sam4cm/include/instance/: tc1.h usart0.h aes.h slcdc.h cmcc0.h usart2.h twi0.h piob.h adc.h rswdt.h chipid.h matrix1.h rstc.h pmc.h cmcc1.h pioa.h pwm.h pioc.h ipc0.h spi0.h matrix0.h smc1.h ipc1.h icm.h uart0.h tc0.h usart3.h rtc.h wdt.h supc.h spi1.h twi1.h usart1.h uart1.h smc0.h efc.h rtt.h trng.h gpbr.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../sam/utils/cmsis/sam4cm/include/component/: wdt.h pio.h rswdt.h tc.h smc.h usart.h aes.h rstc.h trng.h pdc.h rtc.h adc.h efc.h chipid.h ipc.h gpbr.h cmcc.h pwm.h supc.h pmc.h rtt.h slcdc.h spi.h icm.h uart.h twi.h matrix.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp16c.h sam4cms8c.h sam4cms16c.h sam4cmp8c.h sam4cms4c.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_sam4c
    ../../../../../../sam/services/timer_1us/hal_sam4c/: timer_1us_hal.c
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rtc
    ../../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/ipc
    ../../../../../../sam/drivers/ipc/: ipc.c ipc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/boards/atpl360mb
    ../../../../../../sam/boards/atpl360mb/: init.c atpl360mb.h led.h
  group sam/components/display/c0216CiZ
    ../../../../../../sam/components/display/c0216CiZ/: c0216CiZ.c c0216CiZ.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360_exception.h atpl360_hal_spi.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.h general_defs.h
  group common/boards
    ../../../../../../common/boards/: board.h
