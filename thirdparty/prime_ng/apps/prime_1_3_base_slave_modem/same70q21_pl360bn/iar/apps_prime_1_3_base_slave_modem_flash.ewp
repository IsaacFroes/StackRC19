# IAR project apps_prime_1_3_base_slave_modem_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; UDD_ENABLE; __SAME70Q21B__; ARM_MATH_CM7=true; BOARD=PL360BN
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\phy\phy_serial\include; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\usbhs; ..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\pal\include; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mngp; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\mac; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\hal; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\utils; ..\..\..\..\mac\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\pal\mpal; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\sam\boards\pl360bn; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\phy\phy_serial\addons\sniffer_if; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_plcoupxxx; ..\..\..\modem; ..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_1_3_base_slave_modem_flash.bin
  ILINK.IlinkOutputFile: apps_prime_1_3_base_slave_modem_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\same70_no_cache.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime_ng/libs/iar
    ../../../../libs/iar/: libsamM4-prime13-sn-iar.a
  group thirdparty/prime_ng/pal/atpl360_prime/source
    ../../../../pal/atpl360_prime/source/: pal.c pal_rm.c pal_rm.h
  group thirdparty/prime_ng/pal/serial_prime/source
    ../../../../pal/serial_prime/source/: pal_serial.c
  group thirdparty/prime_ng/pal/mpal
    ../../../../pal/mpal/: mpal.c mpal.h
  group thirdparty/prime_ng/pal/include
    ../../../../pal/include/: pal.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: plcoup011_chn_fcc.h plcoup006_2chn.h plcoup011_2chn.h plcoup007_chn_1.h plcoup006_chn_fcc.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/pal
    ../../../../phy/atpl360/coup_tx_config/app_wrp/pal/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl360_plcoupxxx
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl360_plcoupxxx/: coup_conf.h
  group thirdparty/prime_ng/phy/phy_serial/addons/sniffer_if
    ../../../../phy/phy_serial/addons/sniffer_if/: phy_serial_sniffer_if.c phy_serial_sniffer_if.h
  group thirdparty/prime_ng/phy/phy_serial/source
    ../../../../phy/phy_serial/source/: phy_serial.c
  group thirdparty/prime_ng/phy/phy_serial/include
    ../../../../phy/phy_serial/include/: phy_serial.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: hal_aes.c hal_usb.c hal_pib.c hal_cm7_usart.c hal_fu.c hal_cm7_plc.c hal.c hal_reset_handler.c hal_cfg.c hal_pcrc.c hal_usi.c hal_trng.c hal_cm7_uart.c hal_null_dev.c hal_private.h hal_regions.h hal.h conf_prf_if.h conf_timer_1us.h
  group thirdparty/prime_ng/apps/prime_1_3_base_slave_modem
    ../../: user_task.c prime_task.c main.c app.h
  group thirdparty/prime_ng/apps/prime_1_3_base_slave_modem/same70q21_pl360bn
    ../: conf_pal.h conf_app_example.h conf_clock.h conf_uart_serial.h conf_phy_serial.h conf_board.h conf_usb.h conf_usi.h conf_prime_stack.h conf_sleepmgr.h FreeRTOSConfig.h conf_oss.h conf_hal.h conf_mac.h conf_atpl360.h conf_mngp.h
  group thirdparty/prime_ng/apps/prime_1_3_base_slave_modem/same70q21_pl360bn/iar
    ./: asf.h
  group thirdparty/prime_ng/apps/modem
    ../../../modem/: modem_service_task.c modem_service.c modem.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.c prime_hal_wrapper.c prime_hal_wrapper.h prime_api.h prime_api_defs.h
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac_pib.h mac_defs.h mac.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432_defs.h cl_432.h cl_432_api.h
  group thirdparty/prime_ng/conv/sscs/null
    ../../../../conv/sscs/null/: cl_null_api.h cl_null.h
  group thirdparty/prime_ng/mngp
    ../../../../mngp/: mngp.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: queue.c timers.c FreeRTOS_CLI.c list.c tasks.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h queue.h FreeRTOS.h FreeRTOS_CLI.h mpu_wrappers.h timers.h StackMacros.h croutine.h list.h task.h semphr.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/usbhs
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/afec
    ../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/xdmac
    ../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/boards/pl360bn
    ../../../../../../sam/boards/pl360bn/: init.c pl360bn.h led.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_same70
    ../../../../../../sam/services/timer_1us/hal_same70/: timer_1us_hal.c
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70j19.h same70n20b.h same70q21.h same70q19b.h same70j19b.h same70q20b.h same70n20.h same70j20.h same70.h same70n21.h same70q19.h same70q20.h same70j21b.h same70j21.h same70n21b.h same70n19.h same70q21b.h same70j20b.h same70n19b.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70j19.h same70n21.h same70q21.h same70j21.h same70n20b.h same70j20.h same70q20.h same70n19.h same70n19b.h same70n20.h same70q19.h same70q19b.h same70j19b.h same70q21b.h same70n21b.h same70j21b.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: afec0.h utmi.h dacc.h usart1.h spi0.h pioc.h i2sc0.h pioe.h rtc.h sdramc.h gmac.h trng.h uart3.h matrix.h tc3.h pioa.h xdmac.h isi.h usart0.h efc.h tc1.h usart2.h mcan1.h twihs1.h usbhs.h tc2.h hsmci.h pwm1.h chipid.h twihs2.h uart1.h pwm0.h tc0.h icm.h gpbr.h rtt.h uart4.h aes.h twihs0.h afec1.h qspi.h spi1.h ssc.h rswdt.h acc.h mcan0.h i2sc1.h piob.h uart2.h supc.h piod.h smc.h rstc.h wdt.h uart0.h pmc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: aes.h afec.h spi.h rswdt.h efc.h gmac.h wdt.h sdramc.h rtc.h xdmac.h uart.h pio.h gpbr.h qspi.h utmi.h usart.h dacc.h pmc.h rstc.h chipid.h matrix.h twihs.h i2sc.h mcan.h ssc.h usbhs.h supc.h hsmci.h pwm.h smc.h isi.h rtt.h icm.h tc.h trng.h acc.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360.c atpl360_boot.c atpl360_hal_spi.c atpl360_IB.c atpl360_IB.h atpl360_boot.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h atpl360_hal_spi.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_IB_db.c atpl360_IB_db.h atpl360_comm.h general_defs.h
  group common/components/plc/atpl360/addons
    ../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/sniffer_if
    ../../../../../../common/components/plc/atpl360/addons/sniffer_if/: sniffer_if.c sniffer_if_prime.c sniffer_if.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
