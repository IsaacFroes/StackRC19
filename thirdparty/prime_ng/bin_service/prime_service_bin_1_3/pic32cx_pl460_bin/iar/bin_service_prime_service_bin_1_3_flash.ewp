# IAR project bin_service_prime_service_bin_1_3_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4=true; __PIC32CX2051MTSH128__
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\utils\fpu; ..\..; ..\..\..\..\..\..\sam\utils; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\mac; ..\..\..\..\pal\include; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mngp; ..\..\..\..\..\..\common\utils; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\hal; ..\..\..\..\mac\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\components\plc\atpl360\addons; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM4=true; __PIC32CX2051MTSH128__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bin_service_prime_service_bin_1_3_flash.bin
  ILINK.IlinkOutputFile: bin_service_prime_service_bin_1_3_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\pic32cx_0_flash_bin.icf
  ILINK.IlinkProgramEntryLabel: prime_stack_init
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360.c atpl360.h atpl360_boot.c atpl360_boot.h atpl360_exception.h atpl360_hal_spi.c atpl360_hal_spi.h atpl360_IB.c atpl360_IB.h atpl360_IB_db_api.h
  group common/components/plc/atpl360/addons
    ../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/sniffer_if
    ../../../../../../common/components/plc/atpl360/addons/sniffer_if/: sniffer_if.c sniffer_if.h sniffer_if_prime.c
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_comm.h atpl360_IB_db.c atpl360_IB_db.h general_defs.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtc128.h pic32cx1025mtc128S1.h pic32cx1025mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128.h pic32cx1025mtsh128S1.h pic32cx2051mtc128.h pic32cx2051mtc128S1.h pic32cx2051mtg128.h pic32cx2051mtg64.h pic32cx2051mtsh128.h pic32cx2051mtsh128S1.h pic32cx5112mtc128.h pic32cx5112mtc128S1.h pic32cx5112mtg128.h pic32cx5112mtsh128.h pic32cx5112mtsh128S1.h pic32cxmt.h system_pic32cxmt.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: acc.h adc.h aes.h aesb.h chipid.h cmcc.h cpkcc.h dwdt.h emafe.h flexcom.h gpbr.h icm.h ipc.h matrix.h mcspi.h mem2mem.h pdc.h pio.h pmc.h pwm.h qspi.h rstc.h rtc.h rtt.h sefc.h sfr.h sfrbu.h sha.h slcdc.h spi.h supc.h syscwp.h tc.h trng.h twi.h uart.h usart.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: acc.h adc.h aes.h aesb.h chipid.h cmcc0.h cmcc1.h cpkcc.h dwdt.h emafe.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h gpbr.h icm.h ipc0.h ipc1.h matrix0.h matrix1.h matrix2.h matrix3.h mcspi.h mem2mem0.h mem2mem1.h pio.h pmc.h pwm.h qspi.h rstc.h rtc.h rtt.h sefc0.h sefc1.h sfr.h sfrbu.h sha.h slcdc.h spi0.h spi1.h spi2.h spi3.h spi4.h spi5.h spi6.h spi7.h supc.h syscwp.h tc0.h tc1.h tc2.h tc3.h trng.h twi0.h twi1.h twi2.h twi3.h twi4.h twi5.h twi6.h twi7.h uart.h usart0.h usart1.h usart2.h usart3.h usart4.h usart5.h usart6.h usart7.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtc128.h pic32cx1025mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg128.h pic32cx2051mtg64.h pic32cx2051mtsh128.h pic32cx5112mtc128.h pic32cx5112mtg128.h pic32cx5112mtsh128.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group thirdparty/prime_ng/bin_service/prime_service_bin_1_3/pic32cx_pl460_bin
    ../: conf_atpl360.h conf_clock.h conf_hal.h conf_mac.h conf_mngp.h conf_pal.h conf_prime_stack.h
  group thirdparty/prime_ng/bin_service/prime_service_bin_1_3/pic32cx_pl460_bin/iar
    ./: asf.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432.h cl_432_defs.h
  group thirdparty/prime_ng/conv/sscs/null
    ../../../../conv/sscs/null/: cl_null.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: conf_prf_if.h conf_timer_1us.h hal.h hal_private.h hal_regions.h
  group thirdparty/prime_ng/libs/iar
    ../../../../libs/iar/: libsamM4-prime13-sn-iar.a
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac.h mac_defs.h mac_pib.h
  group thirdparty/prime_ng/mngp
    ../../../../mngp/: mngp.h
  group thirdparty/prime_ng/pal/atpl360_prime/source
    ../../../../pal/atpl360_prime/source/: pal.c pal_rm.c pal_rm.h
  group thirdparty/prime_ng/pal/include
    ../../../../pal/include/: pal.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/pal
    ../../../../phy/atpl360/coup_tx_config/app_wrp/pal/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl460
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460/: coup_conf.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_2chn.h pl460_1_5b_chn_fcc.h pl460_plcoup007_chn_1.h pl460_sb_2chn.h pl460_sb_chn_1.h pl460_sb_chn_fcc.h plcoup007_chn_1.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.c prime_api.h prime_api_as.S prime_api_defs.h prime_hal_wrapper.c prime_hal_wrapper.h
