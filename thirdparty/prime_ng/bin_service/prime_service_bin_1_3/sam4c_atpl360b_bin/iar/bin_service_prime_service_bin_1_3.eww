<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bin_service_prime_service_bin_1_3_flash.ewp</path>
	</project>
</workspace>
