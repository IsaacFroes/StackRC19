# IAR project bin_service_prime_service_bin_1_3_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\fpu; ..\..; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\mac; ..\..\..\..\pal\include; ..; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\common\components\plc\atpl360\addons\sniffer_if; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460; ..\..\..\..\prime_api; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mngp; ..\..\..\..\..\..\common\utils; ..\..\..\..\conv\sscs\null; ..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\phy\atpl360\coup_tx_config\app_wrp\pal; ..\..\..\..\hal; ..\..\..\..\mac\include; ..\..\..\..\conv\sscs\iec_4_32; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\components\plc\atpl360\addons; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG55J19__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bin_service_prime_service_bin_1_3_flash.bin
  ILINK.IlinkOutputFile: bin_service_prime_service_bin_1_3_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\samg55_flash_bin.icf
  ILINK.IlinkProgramEntryLabel: prime_stack_init
configuration Release (ARM)
  as the first configuration, except:
  group common/components/plc/atpl360
    ../../../../../../common/components/plc/atpl360/: atpl360.c atpl360.h atpl360_boot.c atpl360_boot.h atpl360_exception.h atpl360_hal_spi.c atpl360_hal_spi.h atpl360_IB.c atpl360_IB.h atpl360_IB_db_api.h
  group common/components/plc/atpl360/addons
    ../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/sniffer_if
    ../../../../../../common/components/plc/atpl360/addons/sniffer_if/: sniffer_if.c sniffer_if.h sniffer_if_prime.c
  group common/components/plc/atpl360/PRIME
    ../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_comm.h atpl360_IB_db.c atpl360_IB_db.h general_defs.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55.h samg55g18.h samg55g19.h samg55j18.h samg55j19.h samg55n19.h system_samg55.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: adc.h chipid.h cmcc.h crccu.h efc.h flexcom.h gpbr.h i2sc.h matrix.h mem2mem.h pdc.h pdmic.h pio.h pmc.h rstc.h rtc.h rtt.h spi.h supc.h tc.h twi.h udp.h uhp.h usart.h wdt.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: adc.h chipid.h cmcc.h crccu.h efc.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h gpbr.h i2sc0.h i2sc1.h matrix.h mem2mem.h pdmic0.h pdmic1.h pioa.h piob.h pmc.h rstc.h rtc.h rtt.h spi0.h spi1.h spi2.h spi3.h spi4.h spi5.h spi6.h spi7.h supc.h tc0.h tc1.h twi0.h twi1.h twi2.h twi3.h twi4.h twi5.h twi6.h twi7.h udp.h uhp.h usart0.h usart1.h usart2.h usart3.h usart4.h usart5.h usart6.h usart7.h wdt.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g18.h samg55g19.h samg55j18.h samg55j19.h samg55n19.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group thirdparty/prime_ng/bin_service/prime_service_bin_1_3/samg55_pl460_bin
    ../: conf_atpl360.h conf_clock.h conf_hal.h conf_mac.h conf_mngp.h conf_pal.h conf_prime_stack.h
  group thirdparty/prime_ng/bin_service/prime_service_bin_1_3/samg55_pl460_bin/iar
    ./: asf.h
  group thirdparty/prime_ng/conv/sscs/iec_4_32
    ../../../../conv/sscs/iec_4_32/: cl_432.h cl_432_defs.h
  group thirdparty/prime_ng/conv/sscs/null
    ../../../../conv/sscs/null/: cl_null.h
  group thirdparty/prime_ng/hal
    ../../../../hal/: conf_prf_if.h conf_timer_1us.h hal.h hal_private.h hal_regions.h
  group thirdparty/prime_ng/libs/iar
    ../../../../libs/iar/: libsamM4-prime13-sn-iar.a
  group thirdparty/prime_ng/mac/include
    ../../../../mac/include/: mac.h mac_defs.h mac_pib.h
  group thirdparty/prime_ng/mngp
    ../../../../mngp/: mngp.h
  group thirdparty/prime_ng/pal/atpl360_prime/source
    ../../../../pal/atpl360_prime/source/: pal.c pal_rm.c pal_rm.h
  group thirdparty/prime_ng/pal/include
    ../../../../pal/include/: pal.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/app_wrp/pal
    ../../../../phy/atpl360/coup_tx_config/app_wrp/pal/: coup_app_wrp.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_conf/pl460
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460/: coup_conf.h
  group thirdparty/prime_ng/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_2chn.h pl460_1_5b_chn_fcc.h pl460_plcoup007_chn_1.h pl460_sb_2chn.h pl460_sb_chn_1.h pl460_sb_chn_fcc.h plcoup007_chn_1.h
  group thirdparty/prime_ng/prime_api
    ../../../../prime_api/: prime_api.c prime_api.h prime_api_as.S prime_api_defs.h prime_hal_wrapper.c prime_hal_wrapper.h
